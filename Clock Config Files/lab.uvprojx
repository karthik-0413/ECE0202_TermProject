# Keil uVision project lab.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.2
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: lab +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source Group 1
    ./: core_cm4_constants.s startup_stm32l476xx.s stm32l476xx_constants.s SysClock.c UART.c main.c thiss.s stepper.s stepper2.s testLED.s key.s SevenSeg.s stepper1.s
    C:/Users/kar304/Downloads/: stdout_USART.c
software components: CMSIS:CORE 5.4.0
